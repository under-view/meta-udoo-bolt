PACKAGECONFIG:append = " amd"
