PACKAGECONFIG = "radeon amdgpu"
