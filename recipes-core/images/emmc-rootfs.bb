inherit amd-image-rootfs
