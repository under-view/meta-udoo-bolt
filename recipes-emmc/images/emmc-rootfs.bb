inherit amd-image-rootfs

AUTO_LOGIN_ROOT = "1"

AMD_INSTALL = " \
    kernel-image \
    "
