require linux-yocto-6.1.inc

PR := "${INC_PR}.1"

KBRANCH:amd ?= "v6.1/standard/base"
SRCREV_machine:amd ?= "b110cf9bbc395fe757956839d8110e72368699f4"
SRCREV_meta:amd ?= "2eaed50911009f9ddbc74460093e17b22ef7daa0"
