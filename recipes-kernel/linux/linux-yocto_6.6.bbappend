require linux-yocto-6.6.inc

PR := "${INC_PR}.1"

KBRANCH:amd ?= "v6.6/standard/base"
SRCREV_machine:amd ?= "ff7ae7b32324226330214197e9b849d1aa35accd"
SRCREV_meta:amd ?= "11390e802ca72f3549b9356f036b17e54afd7a34"
