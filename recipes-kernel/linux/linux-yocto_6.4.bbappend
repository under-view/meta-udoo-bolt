require linux-yocto-6.4.inc

PR := "${INC_PR}.1"

KBRANCH:amd ?= "v6.4/standard/base"
SRCREV_machine:amd ?= "72bad8cd7540f07ab54e08b83ad106dec0df123c"
SRCREV_meta:amd ?= "88ed9ec49099d69f9546d21137191fd747d06ec4"
