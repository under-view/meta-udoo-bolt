require linux-yocto-6.1.inc

PR := "${INC_PR}.1"

KBRANCH:amd ?= "v6.1/standard/base"
SRCREV_machine:amd ?= "581dc1aa2f340fff2cc010067257185fa2c993f9"
SRCREV_meta:amd ?= "36901b5b298e601fe73dd79aaff8b615a7762013"
