require linux-yocto-5.19.inc

PR := "${INC_PR}.1"

KBRANCH:amd ?= "v5.19/standard/base"
SRCREV_machine:amd ?= "aaf4490d1807c49e3e0ceab1372533937ef2c82b"
