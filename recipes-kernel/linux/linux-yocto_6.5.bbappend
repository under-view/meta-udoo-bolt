require linux-yocto-6.5.inc

PR := "${INC_PR}.1"

KBRANCH:amd ?= "v6.5/standard/base"
SRCREV_machine:amd ?= "d04f80df11f7aabc7fc7eb35215731c8027b8c36"
SRCREV_meta:amd ?= "560dad4d406f3134cc55788513be5cecea54a03f"
