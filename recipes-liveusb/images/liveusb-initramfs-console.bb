inherit amd-image-initramfs
