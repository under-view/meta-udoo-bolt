inherit amd-image-initramfs

AUTO_LOGIN_ROOT = "1"

AMD_INSTALL = "\
    udoo-minimal-init \
    "
