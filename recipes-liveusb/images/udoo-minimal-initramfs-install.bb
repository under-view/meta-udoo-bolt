inherit amd-image-initramfs

AMD_INSTALL = "\
    udoo-minimal-init \
    "
